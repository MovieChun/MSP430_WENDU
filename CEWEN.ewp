# IAR project CEWEN.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: basic; user
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group (top)
    ./: main.c main.h
  group BASIC
    basic/: Clock.c Clock.h EXIT.c EXIT.h flash.c flash.h IIC.c IIC.h SCI.c SCI.h uart.c uart2.c
  group USER
    user/: Fstring.c GU900_INIT.c GU900_INIT.h GU900_RUN.c GU900_RUN.h mlx90614.c PC.c PC.h WIFI_INIT.c WIFI_INIT.h WIFI_RUN.c WIFI_RUN.h
